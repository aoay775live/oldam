options:
  parameters:
    author: Perplexity AI
    description: Professional AM Modulator with audio processing
    generate_options: qt_gui
    hier_block_src_path: '.'
    id: am_modulator_pro
    output_language: python
    title: AM Modulator Professional
  states: {}

blocks:
- name: antenna_hz
  id: variable_qtgui_range
  parameters:
    comment: Antenna sway FM wobble depth
    gui_hint: 3,1,1,1
    label: Antenna Effect (Hz)
    start: '0'
    step: '1'
    stop: '120'
    value: '24'
  states: {}
- name: audio_profile
  id: variable_qtgui_chooser
  parameters:
    comment: Audio path profile
    gui_hint: 4,0,1,1
    label: Audio Profile
    label0: Music
    label1: Mic
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: audio_pull_hz
  id: variable_qtgui_range
  parameters:
    comment: Frequency pulling by audio (Hz)
    gui_hint: 1,1,1,1
    label: Audio Pull (Hz)
    start: '0'
    step: '1'
    stop: '8000'
    value: '290'
  states: {}
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Carrier Frequency (Hz)
    start: '0'
    step: '1'
    stop: '24000'
    value: '1000'
  states: {}
- name: drift_hz
  id: variable_qtgui_range
  parameters:
    comment: Slow random carrier drift (Hz)
    gui_hint: 1,2,1,1
    label: Drift (Hz)
    start: '0'
    step: '1'
    stop: '80000'
    value: '500'
  states: {}
- name: hf_boost
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: HF Boost (dB)
    start: '0'
    step: '1'
    stop: '12'
    value: '0'
  states: {}
- name: hum50_level
  id: variable_qtgui_range
  parameters:
    comment: Mains hum injection level
    gui_hint: 2,2,1,1
    label: Hum 50Hz Level
    start: '0'
    step: '0.001'
    stop: '0.15'
    value: '0.05'
  states: {}
- name: hum50_on
  id: variable_qtgui_check_box
  parameters:
    comment: Enable/disable mains hum
    'false': '0'
    gui_hint: 2,3,1,1
    label: Hum 50Hz ON
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: hum_dynamic
  id: variable_qtgui_range
  parameters:
    comment: Dynamic mains sag response
    gui_hint: 3,0,1,1
    label: Hum Dynamic
    start: '0'
    step: '0.1'
    stop: '3.0'
    value: '1.2'
  states: {}
- name: mic_chaos
  id: variable_qtgui_range
  parameters:
    comment: Brutality amount for Mic mode
    gui_hint: 4,1,1,1
    label: Mic Chaos
    start: '0'
    step: '0.1'
    stop: '8'
    value: '4.5'
  states: {}
- name: mod_depth
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Modulation Depth (%)
    start: '0'
    step: '5'
    stop: '150'
    value: '150'
  states: {}
- name: neg_peak_limit
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Negative Peak Limit (%)
    start: '50'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: output_power
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Output Power (%)
    start: '0'
    step: '0.1'
    stop: '100'
    value: '0.5'
  states: {}
- name: parasitic_fm_hz
  id: variable_qtgui_range
  parameters:
    comment: Fast random parasitic FM deviation (Hz)
    gui_hint: 1,3,1,1
    label: Parasitic FM (Hz)
    start: '0'
    step: '10'
    stop: '10000'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: selfosc_level
  id: variable_qtgui_range
  parameters:
    comment: Self-oscillation injection level
    gui_hint: 2,0,1,1
    label: Self-Osc Level
    start: '0'
    step: '0.0001'
    stop: '0.02'
    value: '0.009'
  states: {}
- name: selfosc_on
  id: variable_qtgui_check_box
  parameters:
    comment: Enable/disable self-oscillation tones
    'false': '0'
    gui_hint: 2,1,1,1
    label: Self-Osc ON
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: splatter_drive
  id: variable_qtgui_range
  parameters:
    comment: Positive soft clip drive (tanh)
    gui_hint: 3,2,1,1
    label: Splatter Drive
    start: '0.5'
    step: '0.1'
    stop: '8.0'
    value: '0.9'
  states: {}
- name: waterfall_brightness
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,3,1,1
    label: Waterfall Brightness
    start: '-100'
    step: '1'
    stop: '20'
    value: '-90'
  states: {}
- name: xmode_level
  id: variable_qtgui_range
  parameters:
    comment: Experimental weirdness level
    gui_hint: 4,2,1,1
    label: X-Mode Level
    start: '0'
    step: '0.01'
    stop: '0.50'
    value: '0.2'
  states: {}
- name: xmode_on
  id: variable_qtgui_check_box
  parameters:
    comment: Extra experimental modulation
    'false': '0'
    gui_hint: 4,3,1,1
    label: X-Mode ON
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.02'
    decay_rate: '0.002'
    gain: '1.0'
    max_gain: '8'
    reference: '0.35'
    type: float
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: Stronger AGC
    gain: '1'
    max_gain: '1.8'
    rate: '0.02'
    reference: '0.9'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: Dirty VFO phase/frequency wobble
    sensitivity: 6.283185307179586/samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: White noise for random drift
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: Wideband noise for parasitic FM
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_antenna
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: Antenna random motion source
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_selfosc
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: Self-osc random pitch source
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_xmode
  id: analog_noise_source_x
  parameters:
    amp: '1'
    comment: Experimental crackle/noise
    noise_type: analog.GR_IMPULSE
    seed: '0'
    type: float
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    comment: Hard clip I
    hi: '0.22'
    lo: '-0.22'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    comment: Hard clip Q
    hi: '0.22'
    lo: '-0.22'
  states: {}
- name: analog_rail_ff_freqcmd
  id: analog_rail_ff
  parameters:
    comment: Guard frequency command from runaway/NaN-like bursts
    hi: '6000'
    lo: '-6000'
  states: {}
- name: analog_rail_ff_hum
  id: analog_rail_ff
  parameters:
    comment: Hard-shape hum for extra harmonics
    hi: '0.55'
    lo: '-0.55'
  states: {}
- name: analog_rail_ff_pull
  id: analog_rail_ff
  parameters:
    comment: Limit transients into frequency pulling path
    hi: '0.35'
    lo: '-0.35'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Self-osc tone 1
    freq: '1850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Self-osc tone 2
    freq: '3470'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_hum100
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Add even harmonics/asymmetry
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_hum50
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Mains hum base with rich odd harmonics
    freq: '50'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Stereo IQ Output
    device_name: '"CABLE Input (VB-Audio Virtual C"'
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Audio Input
    device_name: '"VoiceMeeter Output (VB-Audio Vo"'
    samp_rate: samp_rate
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    comment: Envelope follower source
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: DC offset
    const: '1.0'
    type: float
  states: {}
- name: blocks_add_const_vxx_humdyn
  id: blocks_add_const_vxx
  parameters:
    comment: Keep base hum at silence
    const: '1.0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Mix LPF + boosted HF
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    comment: Carrier + audio pull + random drift (Hz)
    num_inputs: '6'
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    comment: Add self-osc tones to audio chain
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    comment: Sum self-osc tones
    type: float
  states: {}
- name: blocks_add_xx_antenna
  id: blocks_add_xx
  parameters:
    comment: Antenna random walk mix
    type: float
  states: {}
- name: blocks_add_xx_asym
  id: blocks_add_xx
  parameters:
    comment: Asymmetric clipping recombine
    type: float
  states: {}
- name: blocks_add_xx_hum
  id: blocks_add_xx
  parameters:
    comment: Build ugly mains hum waveform
    type: float
  states: {}
- name: blocks_add_xx_mic
  id: blocks_add_xx
  parameters:
    comment: Mic low-end + midband mix
    type: float
  states: {}
- name: blocks_add_xx_selfosc
  id: blocks_add_xx
  parameters:
    comment: Random self-osc instantaneous frequency
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_trash
  id: blocks_add_xx
  parameters:
    comment: Collect disconnected legacy branches
    num_inputs: '13'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    comment: I/Q Split
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: To complex
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters:
    comment: Repack clipped I/Q
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    comment: |-
      Negative peak limiter
      max(envelope, min_level)
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_max_xx_1
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_max_xx_2
  id: blocks_max_xx
  parameters:
    comment: Positive half-wave
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_min_xx_0
  id: blocks_min_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_min_xx_1
  id: blocks_min_xx
  parameters:
    comment: Negative hard clip branch
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Apply modulation depth
    const: mod_depth/100.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Output Power Control
    const: output_power/100.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/1.5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_antenna
  id: blocks_multiply_const_vxx
  parameters:
    comment: Antenna-induced FM wobble depth
    const: '1.0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_antenna_fast
  id: blocks_multiply_const_vxx
  parameters:
    comment: Faster random component
    const: antenna_hz*0.35
    type: float
  states: {}
- name: blocks_multiply_const_vxx_antenna_slow
  id: blocks_multiply_const_vxx
  parameters:
    comment: Slow random component
    const: antenna_hz
    type: float
  states: {}
- name: blocks_multiply_const_vxx_audio_pull
  id: blocks_multiply_const_vxx
  parameters:
    comment: Audio-induced VFO pulling
    const: audio_pull_hz
    type: float
  states: {}
- name: blocks_multiply_const_vxx_drift
  id: blocks_multiply_const_vxx
  parameters:
    comment: Random drift depth
    const: drift_hz
    type: float
  states: {}
- name: blocks_multiply_const_vxx_hf
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      HF boost gain
      dB to linear
    const: 10**(hf_boost/20.0)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_hum
  id: blocks_multiply_const_vxx
  parameters:
    comment: Hum enable * level
    const: hum50_on*hum50_level
    type: float
  states: {}
- name: blocks_multiply_const_vxx_hum100
  id: blocks_multiply_const_vxx
  parameters:
    comment: Hum 100 Hz relative level
    const: '0.38'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_humdyn
  id: blocks_multiply_const_vxx
  parameters:
    comment: Dynamic hum depth from envelope
    const: hum_dynamic
    type: float
  states: {}
- name: blocks_multiply_const_vxx_mic_drive
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mic channel brutal overdrive
    const: mic_chaos
    type: float
  states: {}
- name: blocks_multiply_const_vxx_mic_low
  id: blocks_multiply_const_vxx
  parameters:
    comment: Extra low end in mic mode
    const: '0.9'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_mic_norm
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mic overdrive normalization
    const: 1.0/(mic_chaos+1e-6)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_par_fm
  id: blocks_multiply_const_vxx
  parameters:
    comment: Fast parasitic FM depth
    const: parasitic_fm_hz
    type: float
  states: {}
- name: blocks_multiply_const_vxx_posdrive
  id: blocks_multiply_const_vxx
  parameters:
    comment: Soft clip drive
    const: splatter_drive
    type: float
  states: {}
- name: blocks_multiply_const_vxx_posnorm
  id: blocks_multiply_const_vxx
  parameters:
    comment: Soft clip normalize
    const: 1.0/splatter_drive
    type: float
  states: {}
- name: blocks_multiply_const_vxx_selfosc
  id: blocks_multiply_const_vxx
  parameters:
    comment: Self-osc enable * level
    const: selfosc_on*selfosc_level
    type: float
  states: {}
- name: blocks_multiply_const_vxx_selfosc_audio
  id: blocks_multiply_const_vxx
  parameters:
    comment: Audio-dependent self-osc pitch shift
    const: '1000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_selfosc_rand
  id: blocks_multiply_const_vxx
  parameters:
    comment: Self-osc random frequency wander
    const: '1600'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_xmode
  id: blocks_multiply_const_vxx
  parameters:
    comment: Experimental mode injection gain
    const: xmode_on*xmode_level
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: AM Modulation
    type: complex
  states: {}
- name: blocks_multiply_xx_humdyn
  id: blocks_multiply_xx
  parameters:
    comment: Hum tracks audio load
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: Discard legacy fixed self-osc branch
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: Discard legacy oscillator branch
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Music/Mic audio profile selector
    enabled: 'True'
    input_index: audio_profile
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    comment: Soft clip positive branch
    name: '"tanh"'
    type: float
  states: {}
- name: blocks_transcendental_1
  id: blocks_transcendental
  parameters:
    comment: Mic mode hard saturation
    name: '"tanh"'
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    comment: Randomized self-oscillator
    samp_rate: samp_rate
    sensitivity: 6.283185307179586/samp_rate
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Minimum envelope level
    repeat: 'True'
    type: float
    vector: (1.0 - neg_peak_limit/100.0,)
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1.5]'
  states: {}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1.5]'
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    comment: Zero reference for asym clipping
    repeat: 'True'
    type: float
    vector: '[0.0]'
  states: {}
- name: blocks_vector_source_x_carrier
  id: blocks_vector_source_x
  parameters:
    comment: Carrier frequency as stream (Hz)
    repeat: 'True'
    type: float
    vector: (carrier_freq,)
  states: {}
- name: blocks_vector_source_x_selfosc_base
  id: blocks_vector_source_x
  parameters:
    comment: Self-osc base frequency
    repeat: 'True'
    type: float
    vector: '[2200.0]'
  states: {}
- name: epy_block_antenna
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Antenna Chaos LFO', in_sig=None, out_sig=[np.float32])
              self.state = 0.0
              self.slew = 0.0025

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              if np.random.rand() < 0.03:
                  self.slew = float(np.clip(self.slew * (0.6 + 0.9 * np.random.rand()), 3e-4, 0.02))
              steps = np.random.randn(n).astype(np.float32) * self.slew
              walk = np.cumsum(steps, dtype=np.float32) + np.float32(self.state)
              if np.random.rand() < 0.02:
                  walk += np.float32(np.random.uniform(-0.35, 0.35))
              walk = np.clip(walk, -1.0, 1.0)
              self.state = float(walk[-1])
              out[:] = walk * 1.3 + 0.03 * np.random.randn(n).astype(np.float32)
              return n
  states: {}
- name: epy_block_sanitize
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Replace NaN/Inf with 0 to stop feedback loops (AGC, FM phase) from latching dead."""
          def __init__(self):
              gr.sync_block.__init__(self, name='NaN/Inf Sanitizer', in_sig=[np.float32], out_sig=[np.float32])

          def work(self, input_items, output_items):
              output_items[0][:] = np.nan_to_num(input_items[0], nan=0.0, posinf=0.0, neginf=0.0)
              return len(output_items[0])
    comment: 'Guard: GR_IMPULSE noise source emits Inf -> kill Inf/NaN before 0*Inf=NaN poisons graph'
  states: {}
- name: epy_block_selfosc
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Self Osc Chaos', in_sig=None, out_sig=[np.float32])
              self.fs = 48000.0
              self.phase = 0.0
              self.wander = 0.0
              self.step = 0.01

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              if np.random.rand() < 0.02:
                  self.step = float(np.clip(self.step * (0.5 + np.random.rand()), 0.002, 0.05))
              w = np.cumsum(np.random.randn(n).astype(np.float32) * self.step, dtype=np.float32) + np.float32(self.wander)
              w = np.clip(w, -1.0, 1.0)
              self.wander = float(w[-1])
              f = 1200.0 + 5200.0 * w + 60.0 * np.random.randn(n).astype(np.float32)
              ph = self.phase + (2.0 * np.pi / self.fs) * np.cumsum(f, dtype=np.float32)
              s = np.sin(ph) + 0.35 * np.sin(2.07 * ph + 0.4) + 0.2 * np.sin(3.91 * ph + 1.7)
              if np.random.rand() < 0.04:
                  m = min(96, n)
                  i0 = np.random.randint(0, max(1, n - m))
                  s[i0:i0 + m] += np.hanning(m).astype(np.float32) * np.float32(np.random.uniform(0.5, 1.2))
              out[:] = 0.5 * np.tanh(1.8 * s).astype(np.float32)
              self.phase = float(np.mod(ph[-1], 2.0 * np.pi))
              return n
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: |-
      HPF for HF boost
      3 kHz
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: high_pass_filter_2
  id: high_pass_filter
  parameters:
    comment: Mic profile HPF
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '180'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Audio LPF
      6 kHz cutoff
      steep rolloff
    cutoff_freq: '12000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Smooth drift noise to slow wobble
    cutoff_freq: '25'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    comment: Shape parasitic FM noise
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_3
  id: low_pass_filter
  parameters:
    comment: Mic profile LPF
    cutoff_freq: '4500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '800'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_7
  id: low_pass_filter
  parameters:
    comment: Experimental crackle shaping
    cutoff_freq: '7000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '3500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_8
  id: low_pass_filter
  parameters:
    comment: Mic mode low-end boost tap
    cutoff_freq: '260'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '180'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: |-
      PROFESSIONAL AM MODULATOR

      Audio processing:
      - 6 kHz LPF (sharp       cutoff)
      - HF boost (3-6 kHz range)
      - Strong AGC (max gain 20x)
            nModulation:
      - Adjustable depth 0-150%
      - Negative peak limiting
      - 1       kHz carrier default

      Output:
      - Power 0-50% (0.1% steps)
      - Line 2       (Virtual Audio Cable)
      - I/Q stereo
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 5,0,2,2
    label1: After AGC
    label2: After Modulation
    label3: AM Envelope
    name: Modulating Signal
    nconnections: '3'
    size: '4096'
    srate: samp_rate
    type: float
    update_time: '0.16'
    ymax: '3'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 5,2,2,2
    label1: I (In-phase)
    label2: Q (Quadrature)
    name: Output I/Q Signal
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.12'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 7,0,2,4
    int_max: waterfall_brightness + 20
    int_min: waterfall_brightness
    legend: 'False'
    name: Waterfall
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    comment: Envelope smoothing for hum dynamics
    type: float
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00012'
    comment: Antenna random slow envelope (cheap IIR)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_2
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00040'
    comment: Antenna random faster envelope (cheap IIR)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_3
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.005'
    comment: Self-osc random pitch smooth (cheap IIR)
    type: float
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_agc_xx_0, '0']
- [analog_agc_xx_0, '0', blocks_max_xx_2, '0']
- [analog_agc_xx_0, '0', blocks_min_xx_1, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_noise_source_x_0, '0', low_pass_filter_1, '0']
- [analog_noise_source_x_1, '0', low_pass_filter_2, '0']
- [analog_noise_source_x_antenna, '0', blocks_add_xx_trash, '0']
- [analog_noise_source_x_selfosc, '0', blocks_add_xx_trash, '1']
- [analog_noise_source_x_xmode, '0', epy_block_sanitize, '0']
- [analog_rail_ff_0, '0', audio_sink_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_complex_1, '0']
- [analog_rail_ff_0, '0', qtgui_time_sink_x_1, '0']
- [analog_rail_ff_1, '0', audio_sink_0, '1']
- [analog_rail_ff_1, '0', blocks_float_to_complex_1, '1']
- [analog_rail_ff_1, '0', qtgui_time_sink_x_1, '1']
- [analog_rail_ff_freqcmd, '0', analog_frequency_modulator_fc_0, '0']
- [analog_rail_ff_hum, '0', blocks_multiply_xx_humdyn, '0']
- [analog_rail_ff_pull, '0', blocks_multiply_const_vxx_audio_pull, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_3, '0']
- [analog_sig_source_x_2, '0', blocks_add_xx_3, '1']
- [analog_sig_source_x_hum100, '0', blocks_multiply_const_vxx_hum100, '0']
- [analog_sig_source_x_hum50, '0', blocks_add_xx_hum, '0']
- [audio_source_0, '0', high_pass_filter_2, '0']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [audio_source_0, '0', low_pass_filter_8, '0']
- [blocks_abs_xx_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_max_xx_0, '0']
- [blocks_add_const_vxx_humdyn, '0', blocks_multiply_xx_humdyn, '1']
- [blocks_add_xx_0, '0', high_pass_filter_1, '0']
- [blocks_add_xx_1, '0', analog_rail_ff_freqcmd, '0']
- [blocks_add_xx_2, '0', analog_agc2_xx_0, '0']
- [blocks_add_xx_3, '0', blocks_add_xx_trash, '12']
- [blocks_add_xx_antenna, '0', blocks_add_xx_trash, '5']
- [blocks_add_xx_asym, '0', blocks_max_xx_1, '0']
- [blocks_add_xx_hum, '0', analog_rail_ff_hum, '0']
- [blocks_add_xx_mic, '0', blocks_multiply_const_vxx_mic_drive, '0']
- [blocks_add_xx_selfosc, '0', blocks_add_xx_trash, '6']
- [blocks_add_xx_trash, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '0', analog_rail_ff_0, '0']
- [blocks_complex_to_float_0, '1', analog_rail_ff_1, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_max_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_max_xx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_max_xx_1, '0', blocks_min_xx_0, '0']
- [blocks_max_xx_2, '0', blocks_multiply_const_vxx_posdrive, '0']
- [blocks_min_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_min_xx_1, '0', blocks_add_xx_asym, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_2, '0', analog_rail_ff_pull, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_antenna, '0', blocks_add_xx_1, '4']
- [blocks_multiply_const_vxx_antenna_fast, '0', blocks_add_xx_trash, '8']
- [blocks_multiply_const_vxx_antenna_slow, '0', blocks_add_xx_trash, '7']
- [blocks_multiply_const_vxx_audio_pull, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_drift, '0', blocks_add_xx_1, '2']
- [blocks_multiply_const_vxx_hf, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_hum, '0', blocks_add_xx_2, '2']
- [blocks_multiply_const_vxx_hum100, '0', blocks_add_xx_hum, '1']
- [blocks_multiply_const_vxx_humdyn, '0', blocks_add_const_vxx_humdyn, '0']
- [blocks_multiply_const_vxx_mic_drive, '0', blocks_transcendental_1, '0']
- [blocks_multiply_const_vxx_mic_low, '0', blocks_add_xx_mic, '1']
- [blocks_multiply_const_vxx_mic_norm, '0', blocks_selector_0, '1']
- [blocks_multiply_const_vxx_par_fm, '0', blocks_add_xx_1, '3']
- [blocks_multiply_const_vxx_posdrive, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_posnorm, '0', blocks_add_xx_asym, '0']
- [blocks_multiply_const_vxx_selfosc, '0', blocks_add_xx_2, '1']
- [blocks_multiply_const_vxx_selfosc_audio, '0', blocks_add_xx_trash, '10']
- [blocks_multiply_const_vxx_selfosc_rand, '0', blocks_add_xx_trash, '9']
- [blocks_multiply_const_vxx_xmode, '0', blocks_add_xx_1, '5']
- [blocks_multiply_const_vxx_xmode, '0', blocks_add_xx_2, '3']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_xx_humdyn, '0', blocks_multiply_const_vxx_hum, '0']
- [blocks_selector_0, '0', blocks_add_xx_0, '0']
- [blocks_selector_0, '0', high_pass_filter_0, '0']
- [blocks_transcendental_0, '0', blocks_multiply_const_vxx_posnorm, '0']
- [blocks_transcendental_1, '0', blocks_multiply_const_vxx_mic_norm, '0']
- [blocks_vco_f_0, '0', blocks_null_sink_1, '0']
- [blocks_vector_source_x_0, '0', blocks_max_xx_0, '1']
- [blocks_vector_source_x_1, '0', blocks_max_xx_1, '1']
- [blocks_vector_source_x_1_0, '0', blocks_min_xx_0, '1']
- [blocks_vector_source_x_1_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_2, '0', blocks_add_xx_antenna, '0']
- [blocks_vector_source_x_2, '0', blocks_add_xx_antenna, '1']
- [blocks_vector_source_x_2, '0', blocks_add_xx_selfosc, '0']
- [blocks_vector_source_x_2, '0', blocks_add_xx_selfosc, '1']
- [blocks_vector_source_x_2, '0', blocks_add_xx_selfosc, '2']
- [blocks_vector_source_x_2, '0', blocks_max_xx_2, '1']
- [blocks_vector_source_x_2, '0', blocks_min_xx_1, '1']
- [blocks_vector_source_x_2, '0', blocks_multiply_const_vxx_antenna_fast, '0']
- [blocks_vector_source_x_2, '0', blocks_multiply_const_vxx_antenna_slow, '0']
- [blocks_vector_source_x_2, '0', blocks_multiply_const_vxx_selfosc_audio, '0']
- [blocks_vector_source_x_2, '0', blocks_multiply_const_vxx_selfosc_rand, '0']
- [blocks_vector_source_x_2, '0', blocks_vco_f_0, '0']
- [blocks_vector_source_x_2, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_vector_source_x_2, '0', single_pole_iir_filter_xx_2, '0']
- [blocks_vector_source_x_2, '0', single_pole_iir_filter_xx_3, '0']
- [blocks_vector_source_x_carrier, '0', blocks_add_xx_1, '0']
- [blocks_vector_source_x_selfosc_base, '0', blocks_add_xx_trash, '11']
- [epy_block_antenna, '0', blocks_multiply_const_vxx_antenna, '0']
- [epy_block_sanitize, '0', low_pass_filter_7, '0']
- [epy_block_selfosc, '0', blocks_multiply_const_vxx_selfosc, '0']
- [high_pass_filter_0, '0', blocks_multiply_const_vxx_hf, '0']
- [high_pass_filter_1, '0', blocks_abs_xx_0, '0']
- [high_pass_filter_1, '0', blocks_add_xx_2, '0']
- [high_pass_filter_2, '0', low_pass_filter_3, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_drift, '0']
- [low_pass_filter_2, '0', blocks_multiply_const_vxx_par_fm, '0']
- [low_pass_filter_3, '0', blocks_add_xx_mic, '0']
- [low_pass_filter_7, '0', blocks_multiply_const_vxx_xmode, '0']
- [low_pass_filter_8, '0', blocks_multiply_const_vxx_mic_low, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_multiply_const_vxx_humdyn, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_add_xx_trash, '2']
- [single_pole_iir_filter_xx_2, '0', blocks_add_xx_trash, '3']
- [single_pole_iir_filter_xx_3, '0', blocks_add_xx_trash, '4']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
